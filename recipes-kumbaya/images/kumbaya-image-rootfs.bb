require recipes-core/images/kumbaya-image-base.inc

IMAGE_INSTALL += " \
    u-boot-imx \
    alsa-utils \
    "
